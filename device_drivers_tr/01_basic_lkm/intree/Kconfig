## device_drivers_tr/01_basic_lkm/intree/Kconfig
```kconfig
menu "menu my lkms"
config CUSTOM_BASIC_LKM
	tristate "helloworld basic lkm"
	default n
endmenu
```
